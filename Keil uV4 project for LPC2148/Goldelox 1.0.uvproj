# Keil uVision project Goldelox 1.0.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Picture viewer +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ./Goldelox/: goldelox_core.c goldelox_interface.c graphics_objects.c
  group sys_core
    ./sys_core/: CPU_activity.c
  group apps
    ./apps/: app_test.c
